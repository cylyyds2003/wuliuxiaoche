# Keil uVision project STM32F103R8_IOC.uvprojx, settings and files
target STM32F103R8_IOC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103R8_IOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../FunctionCode/BSP;../FunctionCode/BSP/si4463;../FunctionCode/function;../FunctionCode/CAN_Communication;../FunctionCode/CAN_Communication/SlaveControlPanel;../FunctionCode/UserDefinedProtocol;../FunctionCode/APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group BSP
    ../FunctionCode/BSP/BSP_HAL_GPIO/: bsp_hal_gpio.c
    ../FunctionCode/BSP/BSP_HAL_TIME/: bsp_hal_time.c
    ../FunctionCode/BSP/BSP_HAL_CAN/: bsp_hal_can.c
    ../FunctionCode/BSP/BSP_HAL_PS2/: bsp_hal_ps2.c
  group FUNCTION
    ../FunctionCode/function/UnderpanControl_Motor/: UnderpanControl_Motor.c
    ../FunctionCode/function/: separate_button.c
    ../FunctionCode/function/BSP_HAL_UART3DMA232AndTTL/: bsp_hal_uart3dma232AndTTL.c
  group APP
    ../FunctionCode/APP/: app.c data.c
    ../Src/: pid.c
  group CAN_Communication
    ../FunctionCode/CAN_Communication/: CAN_Communication.c CAN_Communication_canconfig.c
    ../FunctionCode/CAN_Communication/SlaveControlPanel/SLAVE_DCMotorMiniwatt/: SLAVE_DCMotorMiniwatt.c
    ../FunctionCode/CAN_Communication/SlaveControlPanel/SLAVE_SteeringEngine_6CH/: SLAVE_SteeringEngine_6CH.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 5.0.1
